# Keil uVision project dac.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: dac
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Group 1
    ./: LPC2300.s vic.c vic.h dac.c timer.c timer.h main.c
